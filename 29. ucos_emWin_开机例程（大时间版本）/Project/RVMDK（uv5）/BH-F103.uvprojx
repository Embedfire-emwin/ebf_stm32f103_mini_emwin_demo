# Keil uVision project BH-F103.uvprojx, settings and files
target F103 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\uCOSIII\uC-CPU;..\..\uCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\..\uCOSIII\uC-LIB;..\..\uCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\uCOSIII\uCOS-III\Source;..\..\uCOSIII\uCOS-III\Ports;..\..\uCOSIII\os_cfg;..\..\STemWinLibrary532\inc;..\..\STemWinLibrary532\Config;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\Mass_Storage\inc;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_it.c
  group APP
    ../../User/APP/: main.c appicon.c common.c pysearch.c keypadapp.c desktop.c Touch_CalibrationApp.c ledDLG.c ADCDLG.c WeatherDLG.c ClockDLG.c USBDLG.c CalculatorDLG.c PhoneDLG.c MessageDLG.c
  group BSP
    ../../User/BSP/: bsp.c
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../../User/BSP/usart/: bsp_usart.c
    ../../User/BSP/font/: fonts.c
    ../../User/BSP/Key/: bsp_key.c
    ../../User/BSP/TPad/: bsp_tpad.c
    ../../User/BSP/Beep/: bsp_beep.c
    ../../User/BSP/dht11/: bsp_dht11.c
    ../../User/BSP/ds18b20/: bsp_ds18b20.c
    ../../User/BSP/adc/: bsp_adc.c
    ../../User/BSP/rtc/: bsp_rtc.c bsp_date.c bsp_calendar.c
    ../../User/BSP/gsm_gprs/: bsp_gsm_gprs.c bsp_gsm_usart.c
  group USB_APP
    ../../Libraries/Mass_Storage/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USB_Device
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STemWin_V532
    ../../STemWinLibrary532/Lib/: STemWin532_CM3_Keil.lib
    ../../STemWinLibrary532/Config/: GUIConf.c LCDConf_FlexColor_Template.c GUIFont_Port.c GUIPicture_Port.c
    ../../STemWinLibrary532/OS/: GUI_X_OS.c GUI_X_Touch_Analog.c
  group uC/CPU
    ../../uCOSIII/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../uCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm cpu.h
  group uC/LIB
    ../../uCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../uCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../uCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../../uCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group os_cfg
    ../../uCOSIII/os_cfg/: os_cfg_app.h app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h
  group FatFs
    ../../User/FATFS/drivers/: fatfs_sd_sdio.c fatfs_flash_spi.c
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: cc936.c syscall.c firecc936.c
  group DOC
    ../../Doc/: readme.txt
