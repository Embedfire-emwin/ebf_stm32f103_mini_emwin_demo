# Keil uVision project BH-F103.uvprojx, settings and files
target emWin_basic (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\STemWinLibrary532\inc;..\..\STemWinLibrary532\Config;..\..\User\FATFS;..\..\Demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Appli/Demo
    ../../Demo/: PictureApp.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/Led/: bsp_led.c
    ../../User/lcd/: bsp_ili9341_lcd.c bsp_xpt2046_lcd.c
    ../../User/font/: fonts.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/usart/: bsp_usart.c
    ../../User/Key/: bsp_key.c
  group STemWin_V532
    ../../STemWinLibrary532/Lib/: STemWin532_CM3_Keil.lib
    ../../STemWinLibrary532/OS/: GUI_X.c GUI_X_Touch_Analog.c
    ../../STemWinLibrary532/Config/: GUIConf.c LCDConf_FlexColor_Template.c GUIFont_Port.c GUIPicture_Port.c
  group FatFs
    ../../User/FATFS/drivers/: fatfs_flash_spi.c fatfs_sd_sdio.c
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: cc936.c
  group DOC
    ../../Doc/: readme.txt
